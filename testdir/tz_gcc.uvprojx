# Keil uVision project tz_gcc.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: tz_gcc
  group Source Group 1
    ./src/: main.c retarget.c SecureAttrib.c system_TC8234.c clk.h cmsis_gcc.h core_armv8mbl.h core_cmFunc.h core_cmInstr.h partition_TC8234.h sys.h system_TC8234.h TC8234.h uart.h
